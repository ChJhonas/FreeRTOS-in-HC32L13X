# Keil uVision project HC32_FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\HC32_Common;..\HC32_Driver\inc;..\HC32_Driver\src;..\HC32_Source;..\FreeRTOS\Source;..\FreeRTOS\Source\include;..\FreeRTOS\Portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group HC32_Common
    ../HC32_Common/: interrupts_hc32l13x.c startup_hc32l13x.s system_hc32l13x.c
  group HC32_Driver
    ../HC32_Driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group HC32_Source
    ../HC32_Source/: main.c user.c
  group FreeRTOS kernel
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Portable
    ../FreeRTOS/Portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/Portable/MemMang/: heap_4.c
  group README
    ../: Readme.txt
software components: CMSIS:CORE 5.4.0
